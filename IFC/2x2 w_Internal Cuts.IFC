Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 2x2 w_Internal Cuts.IFC
Time: 2024-03-11T12:02:39
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 in

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 in
