Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: G2 w_ Hood.IFC
Time: 2024-03-11T12:37:41
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
